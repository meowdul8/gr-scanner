options:
  parameters:
    author: Aaron Rossetto
    copyright: (C) 2022 Aaron Rossetto
    generate_options: no_gui
    id: p25_scanner_e310_2ch
    output_language: python
    run_options: run
    title: P25 Scanner (E310, 2ch)
  states: {}

blocks:
- name: channel_sample_rate
  id: variable
  parameters:
    value: (master_clock_rate / 224.0)
  states: {}
- name: demod_gain
  id: variable
  parameters:
    value: channel_sample_rate / (2.0 * math.pi * (1800 * 3) / 8)
  states: {}
- name: ettus_rfnoc_graph
  id: ettus_rfnoc_graph
  parameters:
    clock_source_0: ''
    clock_source_1: ''
    clock_source_2: ''
    clock_source_3: ''
    clock_source_4: ''
    clock_source_5: ''
    clock_source_6: ''
    clock_source_7: ''
    dev_addr: device_args
    dev_args: '"master_clock_rate={}".format(master_clock_rate)'
    num_mboards: '1'
    time_source_0: ''
    time_source_1: ''
    time_source_2: ''
    time_source_3: ''
    time_source_4: ''
    time_source_5: ''
    time_source_6: ''
    time_source_7: ''
  states: {}
- name: master_clock_rate
  id: variable
  parameters:
    value: '19600000'
  states: {}
- name: radio_center_freq
  id: variable
  parameters:
    value: '852500000'
  states: {}
- name: radio_gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: vec_size
  id: variable
  parameters:
    value: '128'
  states: {}
- name: analog_demod_cc
  id: analog_quadrature_demod_cf
  parameters:
    alias: quad_demod_control_channel
    gain: demod_gain
  states: {}
- name: analog_demod_tc
  id: analog_quadrature_demod_cf
  parameters:
    alias: quad_demod_traffic_channel
    gain: demod_gain
  states: {}
- name: back_end_module_name
  id: parameter
  parameters:
    short_id: b
    type: str
    value: ''''''
  states: {}
- name: back_end_module_parameters
  id: parameter
  parameters:
    short_id: p
    type: str
    value: ''''''
  states: {}
- name: blocks_vector_to_stream_cc
  id: blocks_vector_to_stream
  parameters:
    alias: vector_to_stream_control_channel
    num_items: vec_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_tc
  id: blocks_vector_to_stream
  parameters:
    alias: vector_to_stream_traffic_channel
    num_items: vec_size
    type: complex
  states: {}
- name: cc_offset
  id: parameter
  parameters:
    label: cc_offset
    type: eng_float
    value: '1632500.0'
  states: {}
- name: dc_blocker_cc
  id: dc_blocker_xx
  parameters:
    alias: dc_blocker_control_channel
    length: 1024+0*(int(channel_sample_rate / 4800.0) * 4)
    long_form: 'False'
    type: ff
  states: {}
- name: dc_blocker_tc
  id: dc_blocker_xx
  parameters:
    alias: dc_blocker_traffic_channel
    length: 1024+0*(int(channel_sample_rate / 4800.0) * 4)
    long_form: 'False'
    type: ff
  states: {}
- name: device_args
  id: parameter
  parameters:
    label: device_args
    short_id: d
    type: str
    value: ''''''
  states: {}
- name: ettus_rfnoc_ddc_cc
  id: ettus_rfnoc_ddc
  parameters:
    alias: rfnoc_ddc_control_chan
    block_args: ''
    device_select: '-1'
    freq: cc_offset
    instance_index: '0'
    num_chans: '1'
    output_rate: channel_sample_rate
  states: {}
- name: ettus_rfnoc_ddc_tc
  id: ettus_rfnoc_ddc
  parameters:
    alias: rfnoc_ddc_traffic_chan
    block_args: ''
    device_select: '-1'
    freq: tc_offset
    instance_index: '1'
    num_chans: '1'
    output_rate: channel_sample_rate
  states: {}
- name: ettus_rfnoc_rx_radio
  id: ettus_rfnoc_rx_radio
  parameters:
    agc: Default
    alias: rfnoc_rx_radio
    antenna: RX2
    bandwidth: master_clock_rate
    block_args: '"spp={}".format(vec_size)'
    dc_offset: 'True'
    device_select: '-1'
    frequency: radio_center_freq
    gain: radio_gain
    instance_index: '0'
    iq_balance: 'True'
    num_chans: '1'
    rate: master_clock_rate
  states: {}
- name: ettus_rfnoc_rx_streamer_cc
  id: ettus_rfnoc_rx_streamer
  parameters:
    alias: rfnoc_rx_streamer_control_channel
    args: '"spp={}".format(vec_size)'
    num_chans: '1'
    otw: sc16
    output_type: fc32
    vlen: vec_size
  states: {}
- name: ettus_rfnoc_rx_streamer_tc
  id: ettus_rfnoc_rx_streamer
  parameters:
    alias: rfnoc_rx_streamer_traffic_channel
    args: '"spp={}".format(vec_size)'
    num_chans: '1'
    otw: sc16
    output_type: fc32
    vlen: vec_size
  states: {}
- name: ettus_rfnoc_split_stream
  id: ettus_rfnoc_split_stream
  parameters:
    alias: rfnoc_split_stream
    block_args: ''
    device_select: '-1'
    instance_index: '0'
    num_branches: '2'
    num_chans: '1'
  states: {}
- name: front_end_interface
  id: scanner_front_end_interface
  parameters:
    alias: front_end_interface
    input_channel_list: cc_pdus, tc_pdus
    module_and_class_name: back_end_module_name
    module_and_class_parameters: back_end_module_parameters
    output_channel_list: radio_freq, radio_gain, cc_offset, tc_offset
  states: {}
- name: fsk4_cc
  id: scanner_fsk4_demodulator
  parameters:
    alias: fsk4_control_channel
    sample_rate: '87500'
    symbol_rate: '4800'
  states: {}
- name: fsk4_tc
  id: scanner_fsk4_demodulator
  parameters:
    alias: fsk4_traffic_channel
    sample_rate: '87500'
    symbol_rate: '4800'
  states: {}
- name: low_pass_filter_cc
  id: low_pass_filter
  parameters:
    alias: lpf_control_channel
    cutoff_freq: '12500'
    decim: '1'
    gain: '1'
    samp_rate: channel_sample_rate
    type: fir_filter_ccf
    width: '3000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_tc
  id: low_pass_filter
  parameters:
    alias: lpf_traffic_channel
    cutoff_freq: '12500'
    decim: '1'
    gain: '1'
    samp_rate: channel_sample_rate
    type: fir_filter_ccf
    width: '3000'
    win: firdes.WIN_HAMMING
  states: {}
- name: p25_framer_cc
  id: scanner_p25_frame_decoder
  parameters:
    alias: p25_framer_control_channel
    debug: '0'
  states: {}
- name: p25_framer_tc
  id: scanner_p25_frame_decoder
  parameters:
    alias: p25_framer_traffic_channel
    debug: '0'
  states: {}
- name: rrc_filter_cc
  id: root_raised_cosine_filter
  parameters:
    alias: rrc_control_channel
    alpha: '0.2'
    decim: '1'
    gain: '1'
    ntaps: '360'
    samp_rate: channel_sample_rate
    sym_rate: '4800'
    type: fir_filter_fff
  states: {}
- name: rrc_filter_tc
  id: root_raised_cosine_filter
  parameters:
    alias: rrc_traffic_channel
    alpha: '0.2'
    decim: '1'
    gain: '1'
    ntaps: '360'
    samp_rate: channel_sample_rate
    sym_rate: '4800'
    type: fir_filter_fff
  states: {}
- name: tc_offset
  id: parameter
  parameters:
    label: tc_offset
    type: eng_float
    value: '-600000.0'
  states: {}
- name: virtual_sink_cc
  id: virtual_sink
  parameters:
    alias: virtual_sink_control_channel
    stream_id: control_chan_bb
  states: {}
- name: virtual_sink_tc
  id: virtual_sink
  parameters:
    alias: virtual_sink_traffic_channel
    stream_id: traffic_chan_bb
  states: {}
- name: virtual_source_cc
  id: virtual_source
  parameters:
    alias: virtual_source_control_channel
    stream_id: control_chan_bb
  states: {}
- name: virtual_source_tc
  id: virtual_source
  parameters:
    alias: virtual_source_traffic_channel
    stream_id: traffic_chan_bb
  states: {}

connections:
- [analog_demod_cc, '0', dc_blocker_cc, '0']
- [analog_demod_tc, '0', dc_blocker_tc, '0']
- [blocks_vector_to_stream_cc, '0', virtual_sink_cc, '0']
- [blocks_vector_to_stream_tc, '0', virtual_sink_tc, '0']
- [dc_blocker_cc, '0', rrc_filter_cc, '0']
- [dc_blocker_tc, '0', rrc_filter_tc, '0']
- [ettus_rfnoc_ddc_cc, '0', ettus_rfnoc_rx_streamer_cc, '0']
- [ettus_rfnoc_ddc_tc, '0', ettus_rfnoc_rx_streamer_tc, '0']
- [ettus_rfnoc_rx_radio, '0', ettus_rfnoc_split_stream, '0']
- [ettus_rfnoc_rx_streamer_cc, '0', blocks_vector_to_stream_cc, '0']
- [ettus_rfnoc_rx_streamer_tc, '0', blocks_vector_to_stream_tc, '0']
- [ettus_rfnoc_split_stream, '0', ettus_rfnoc_ddc_cc, '0']
- [ettus_rfnoc_split_stream, '1', ettus_rfnoc_ddc_tc, '0']
- [front_end_interface, out0, ettus_rfnoc_rx_radio, freq]
- [front_end_interface, out1, ettus_rfnoc_rx_radio, gain]
- [front_end_interface, out2, ettus_rfnoc_ddc_cc, freq]
- [front_end_interface, out3, ettus_rfnoc_ddc_tc, freq]
- [fsk4_cc, '0', p25_framer_cc, '0']
- [fsk4_tc, '0', p25_framer_tc, '0']
- [low_pass_filter_cc, '0', analog_demod_cc, '0']
- [low_pass_filter_tc, '0', analog_demod_tc, '0']
- [p25_framer_cc, p25, front_end_interface, in0]
- [p25_framer_tc, p25, front_end_interface, in1]
- [rrc_filter_cc, '0', fsk4_cc, '0']
- [rrc_filter_tc, '0', fsk4_tc, '0']
- [virtual_source_cc, '0', low_pass_filter_cc, '0']
- [virtual_source_tc, '0', low_pass_filter_tc, '0']

metadata:
  file_format: 1
